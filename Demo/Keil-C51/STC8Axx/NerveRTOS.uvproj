# Keil uVision project NerveRTOS.uvproj, settings and files
target Keil uVision5 project (MCS-51)
  device: AT89C51RE2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFFF)  XRAM(0-0x1EFF) CLOCK(60000000) MODP2
  output: NerveRTOS +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\App;.\ASM;.\Func;.\Drive;.\OS;.\User;..\..\..\softos;..\..\..\softos\include;..\..\..\softos\link\8051;..\..\..\softos\stdfunc;..\..\..\softos\stdfunc\include
  asm include: ..\Src\ASM
  link misc: REMOVEUNUSED
  group User
    ./User/: Main.c
    ../../../softos/stdfunc/: LinkList.c print.c str.c
  group App
    ./App/: test.c
  group OS
    ../../../softos/: osClock.c osMemory.c osPost.c osSignal.c osTask.c
    ../../../softos/link/8051/: osLink.s osLink.c
  group Func
    ./Func/: BDH_Lib.c Byte_Lib.c delay_Lib.c String_Lib.c UARTApp.c
  group Drive
    ./Drive/: Interrupt.c Power.c Timer.c UART.c WDT.c
  group ASM
    ./ASM/: STARTUP.A51 NOP.A51
