/*------------------------------------------------------------------------------------------------------------------------
 * 文件名称：String_Lib.c

 * 文件内容：软件延时

 * 文件版本：1.0.0

 * 文件作者：麦特实验室

 * 开发环境：STC8A8K64S4A12@22.1184MHz芯片 & Keil uVision 5 

 * 注    意：
------------------------------------------------------------------------------------------------------------------------*/
/*------------------------------------------------------------------------------------------------------------------------
                                                  加载头文件区
------------------------------------------------------------------------------------------------------------------------*/	

#include "Inc_Basic.h"//基本库
#include "String_Lib.h"
/*------------------------------------------------------------------------------------------------------------------------
 * 函数名称：SComp

 * 函数功能：字符串比较

 * 输入参数：*a(原字符串)*b(比较字符串)

 * 输出参数：1:相同 0:不相同

 * 注    意：无
------------------------------------------------------------------------------------------------------------------------*/
u2 SComp(const char *a,const char *b)
{
	u8 i = 0;
	while(1)
	{
	 	if(*a == 0 && i > 0)
			return 1;
		if(*a != *b)
			return 0;	
		a++;
		b++;
		i++;
	}
}
/*------------------------------------------------------------------------------------------------------------------------
 * 函数名称：ScC

 * 函数功能：字符串小写转换大写

 * 输入参数：*a(字符串)

 * 输出参数：无

 * 注    意：无
------------------------------------------------------------------------------------------------------------------------*/
void ScC(char *a)
{
	while(1)
	{
		if(*a == 0)
			break;
		if(*a > 96 && *a < 123)
		{	
			*a -= 32;
		}
		a++;
	}
}
/*------------------------------------------------------------------------------------------------------------------------
 * 函数名称：SAa

 * 函数功能：字符串大写转换小写

 * 输入参数：*a(字符串)

 * 输出参数：无

 * 注    意：无
------------------------------------------------------------------------------------------------------------------------*/
void SAa_lookup(char *a,char sdata)
{
	while(1)
	{
		if(*a == 0 || *a == sdata)
			break;
		if(*a > 64 && *a < 91)
		{
			*a += 32;
		}
		a++;
	}	
}
/*------------------------------------------------------------------------------------------------------------------------
 * 函数名称：ScC_lookup

 * 函数功能：字符串小写转换大写，发现与字符串相同，自动停止

 * 输入参数：*a(字符串)

 * 输出参数：无

 * 注    意：无
------------------------------------------------------------------------------------------------------------------------*/
void ScC_lookup(char *a,char sdata)
{
	while(1)
	{
		if(*a == 0 || *a == sdata)
			break;
		if(*a > 96 && *a < 123)
		{	
			*a -= 32;
		}
		a++;
	}
}
/*------------------------------------------------------------------------------------------------------------------------
 * 函数名称：SLookup

 * 函数功能：字符串，字符定位

 * 输入参数：*a(字符串)sdata(字符)

 * 输出参数：位置

 * 注    意：无
------------------------------------------------------------------------------------------------------------------------*/
u8 SLookup(const char *a,char sdata)
{
	u8 SL_F0 = 0;
	while(SL_F0 < 254)
	{
		if(*a == sdata)
			return SL_F0;
		SL_F0++;
		a++;
	}
	return SL_F0;
}
u32 ASCII_DEC(const char *a)
{
	u32 A_DEC = 0;
	while(1)
	{
		if(*a > 47 && *a < 58)
			A_DEC = (A_DEC * 10) + (*a  - 48); 
		else
			break;
		a++;
	}
	return A_DEC;
}

/*------------------------------------------------------------------------------------------------------------------------
                                                  END
------------------------------------------------------------------------------------------------------------------------*/