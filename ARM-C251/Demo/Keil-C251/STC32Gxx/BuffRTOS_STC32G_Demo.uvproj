# Keil uVision project BuffRTOS_STC32G_Demo.uvproj, settings and files
target Drtos_STC32G_Demo (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: BuffRTOS_Demo +hex
  link misc: REMOVEUNUSED
  group User
    ./Src/User/: main.c osConfig.h
  group OS
    ../../../Drtos/: osMemory.c osPost.c osSignal.c osTask.c osTime.c
    ../../../Drtos/stdfunc/: LinkList.c str.c
    ../../../Drtos/link/MCS251/: osLink.c
  group Func
    ../../../Drtos/link/MCS251/: print.c
  group Drive
    ./Src/Drive/isr/: STC32G_ADC_Isr.c STC32G_CAN_Isr.c STC32G_Compare_Isr.c STC32G_DMA_Isr.c STC32G_Exti_Isr.c STC32G_GPIO_Isr.c STC32G_I2C_Isr.c STC32G_LCM_Isr.c STC32G_LIN_Isr.c STC32G_PWM_Isr.c STC32G_RTC_Isr.c STC32G_SPI_Isr.c STC32G_Timer_Isr.c STC32G_UART_Isr.c
    ./Src/Drive/src/: STC32G_ADC.c STC32G_CAN.c STC32G_Clock.c STC32G_Compare.c STC32G_Delay.c STC32G_DMA.c STC32G_EEPROM.c STC32G_Exti.c STC32G_GPIO.c STC32G_I2C.c STC32G_LCM.c STC32G_LIN.c STC32G_NVIC.c STC32G_PWM.c STC32G_RTC.c STC32G_Soft_I2C.c STC32G_Soft_UART.c STC32G_SPI.c STC32G_Timer.c STC32G_UART.c STC32G_USART.c STC32G_WDT.c
