/*------------------------------------------------------------------------------------------------------------------------
 * 文件名称：Byte_Lib.c

 * 文件内容：

 * 文件版本：1.0.0

 * 文件作者：阿顿

 * 开发环境：STC8A8K64S4A12@22.1184MHz芯片 & Keil uVision 5 

 * 注    意：
------------------------------------------------------------------------------------------------------------------------*/
/*------------------------------------------------------------------------------------------------------------------------
                                                  加载头文件区
------------------------------------------------------------------------------------------------------------------------*/	
#include "Inc_Basic.h"//基本库
#include "Byte_Lib.h"
/*------------------------------------------------------------------------------------------------------------------------
 * 函数名称：byte_write

 * 函数功能：字节位写操作

 * 输入参数：byte_data(数据),byte_address(位置),bit_data(位值)

 * 输出参数：处理后数据

 * 注    意：无
------------------------------------------------------------------------------------------------------------------------*/
u8 byte_write(u8 byte_data,u8 byte_address,u2 bit_data)
{
	 if(bit_data)
	 {
	 	  byte_data = byte_data | (0x01 << byte_address);
	 }
	 else
	 {
	  	 byte_data = byte_data & (~(0x01 << byte_address));
	 }
	return byte_data ;
}
/*------------------------------------------------------------------------------------------------------------------------
 * 函数名称：byte_write

 * 函数功能：字节位写操作

 * 输入参数：byte_data(数据),byte_address(位置)

 * 输出参数：位值

 * 注    意：无
------------------------------------------------------------------------------------------------------------------------*/
u2 byte_read(u8 byte_data,u8 byte_address)
{
 	if(byte_data & (0x01 << byte_address))
	{
		return 1;
	}
	else
	{
		return 0;
	}
}
/*------------------------------------------------------------------------------------------------------------------------
 * 函数名称：byte_not

 * 函数功能：字节位对调操作

 * 输入参数：byte_data(数据),byte_address(位置)

 * 输出参数：处理完数据

 * 注    意：无
------------------------------------------------------------------------------------------------------------------------*/
u8 byte_not(u8 byte_data)
{
 	 u8 byte_not_F0,byte_not_Temp0;
	 for(byte_not_F0 = 0; byte_not_F0 < 8 ; byte_not_F0++)
	 {
	  	 byte_not_Temp0 = byte_not_Temp0 |((byte_data & (0x01 << (7 - byte_not_F0))) > 0 ? 0x01 << byte_not_F0 :0x00);
	 }
	 return byte_not_Temp0; 
}
/*------------------------------------------------------------------------------------------------------------------------
                                                  END
------------------------------------------------------------------------------------------------------------------------*/