/*------------------------------------------------------------------------------------------------------------------------
 * 文件名称：Main.c

 * 文件内容：

 * 文件版本：1.0.0

 * 文件作者：麦特实验室

 * 开发环境：STC8A8K64S4A12@22.1184MHz芯片 & Keil uVision 5 

 * 注    意：
------------------------------------------------------------------------------------------------------------------------*/

/*------------------------------------------------------------------------------------------------------------------------

								****      **   *********    ********     **     	 	  **   *********
								** **     **   *********    **      **    **    		 **		 *********
								**  **    **   **           **       **    **  		  **     **
								**   **   **   *********    **      **      **  	 **      *********
								**    **  **   *********    **********       ** 	**       *********
								**     ** **   **           **   **           ** **        **
								**      ****   *********    **     **          ***         *********
								**       ***   *********    **       **         *          *********


							      ********       **********       ******         **************
										**      **     **********      **    **        **
										**       **        **        **        **      **
										**      **         **       **          **     **
										**********         **      **            **    **************
										**   **            **       **          **                 **
										**     **          **        **        **                  **
										**       **        **          *********       **************
			
								---------------------欢迎使用NerveRTOS开发单片机-----------------------
------------------------------------------------------------------------------------------------------------------------*/
/*------------------------------------------------------------------------------------------------------------------------
                                                  加载头文件区
------------------------------------------------------------------------------------------------------------------------*/
		
#include "Inc_Basic.h"//基本库
#include "System_Control.h"//NreveRTOS引导程序
#include "test.h"//交通灯测试

/****************************test**************************/
void test()
{
	OpenTask(12);
}
void test2()
{
	P01 = ~P01;
}
void test1()
{
	u16 i = 0;
	TaskLoad(11,Task_NULL,1,NULL,test1);//创建任务
	while(1)
	{
		if(i++ >= 50)
		{
			i = 0;
			P00 = !P00;
		}
		TaskDelayMs(10);
	}
}
/******************************************************/

/*------------------------------------------------------------------------------------------------------------------------
 * 函数名称：main

 * 函数功能：主函数

 * 输入参数：无

 * 输出参数：无

 * 注    意：无
------------------------------------------------------------------------------------------------------------------------*/
void main()
{
	System_Init();//系统初始化
	TaskLoad(15,Task_Time,10,500,test);//创建任务
	TaskLoad(11,Task_Time,1,500,test1);//创建任务
	TaskLoad(12,Task_NULL,10,NULL,test2);//创建任务
//	TaskLoad(15,Task_EX0,9,NULL,test2);//创建任务
//	Step0();//初始化交通灯
	while(1)
	{
			P07 = !P07;
			delay_ms(500);
	}
}
/*------------------------------------------------------------------------------------------------------------------------
                                                  END
------------------------------------------------------------------------------------------------------------------------*/
