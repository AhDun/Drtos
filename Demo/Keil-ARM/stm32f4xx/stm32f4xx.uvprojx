# Keil uVision project stm32f4xx.uvprojx, settings and files
target buffos arm demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: .\Src\App;.\Src\Drive;.\Src\Drive\CMSIS;.\Src\Drive\STM32F4xx_StdPeriph_Driver;.\Src\Func;.\Src\User;..\..\..\buffos;..\..\..\buffos\stdfunc;..\..\..\buffos\include;..\..\..\buffos\stdfunc\include;.\Src\Drive\STM32F4xx_StdPeriph_Driver\inc;.\Src\CPU;..\..\..\buffos\link\M3M4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./Src/User/: main.c
  group App
    ./Src/App/: Demo.c
  group OS
    ../../../buffos/: osMemory.c osPost.c osSignal.c osTask.c osTime.c osTool.c
    ../../../buffos/link/M3M4F/: osLink.c osLink.s
    ./Src/User/: osConfig.h
  group Func
    ./Src/Func/: rtc.c SysTick.c tftlcd.c usart.c sram.c
    ../../../buffos/stdfunc/: LinkList.c print.c str.c
  group Drive
    ./Src/Drive/: stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
    ./Src/Drive/CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f40_41xxx.s system_stm32f4xx.c system_stm32f4xx.h
    ./Src/Drive/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
