/*------------------------------------------------------------------------------------------------------------------------
 * 文件名称：BDH_Lib.c

 * 文件内容：

 * 文件版本：1.0.0

 * 文件作者：麦特实验室

 * 开发环境：STC8A8K64S4A12@22.1184MHz芯片 & Keil uVision 5 

 * 注    意：
------------------------------------------------------------------------------------------------------------------------*/
/*------------------------------------------------------------------------------------------------------------------------
                                                  加载头文件区
------------------------------------------------------------------------------------------------------------------------*/	
#include "Inc_Basic.h"//基本库
#include "BDH_Lib.h"

/*------------------------------------------------------------------------------------------------------------------------
 * 函数名称：Bin_Hex

 * 函数功能：字符串表示的二进制转换为十六进制

 * 输入参数：*Bin(字符串表示的二进制)

 * 输出参数：十六进制

 * 注    意：无
------------------------------------------------------------------------------------------------------------------------*/
u8 Bin_Hex(const char *Bin) 
{
	u8 Bin_F0 = 0,Bin_Dat = 0;
	while(1)
	{
		if(*Bin == 48)
		{
			Bin_Dat <<= 1;
			Bin_F0++;
		}
		else if(*Bin == 49)
		{
			Bin_Dat <<= 1;
			Bin_Dat |= 0x01;
			Bin_F0++;
		}
		else if(*Bin == 0){
			break;
		}
		if(Bin_F0 >= 8){
			break;
		}
		Bin++;
	}
	return Bin_Dat;	
}
/*------------------------------------------------------------------------------------------------------------------------
 * 函数名称：Hex_ASCII

 * 函数功能：十六进制转换为ASCII码形式的十六进制

 * 输入参数：Hex(十六进制数值)

 * 输出参数：高八位(ASCII码形式的十六进制)低八位(ASCII码形式的十六进制)

 * 注    意：无
------------------------------------------------------------------------------------------------------------------------*/
u16 Hex_ASCII(u8 Hex)
{
 	u16 ASCII_Dat;
	u8 Hex_Temp;
	Hex_Temp = Hex & 0x0F;
	if(Hex_Temp < 10)
	{
		Hex_Temp += 48;
	}
	else
	{
	 	Hex_Temp = Hex_Temp % 10;
		Hex_Temp += 65;
	}
	ASCII_Dat = Hex_Temp;
	Hex_Temp = 	Hex >> 4;
	if(Hex_Temp < 10)
	{
		Hex_Temp += 48;
	}
	else
	{
	 	Hex_Temp = Hex_Temp % 10;
		Hex_Temp += 65;
	}
	ASCII_Dat = ASCII_Dat |(Hex_Temp << 8);
	return ASCII_Dat; 
}
/*------------------------------------------------------------------------------------------------------------------------
                                                  END
------------------------------------------------------------------------------------------------------------------------*/